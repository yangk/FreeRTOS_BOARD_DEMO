# IAR project FreeRTOS.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: VECT_TAB_FLASH; IAR_ARM_CM3
  ICCARM.CCDiagSuppress: Pa082, pe191
  ICCARM.CCIncludePath2: .; ..\Library\inc; ..\OS\include; ..\OS\common\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: .
  OBJCOPY.OOCOutputFile: FreeRTOS.bin
  ILINK.IlinkOutputFile: FreeRTOS.out
  ILINK.IlinkIcfFile: ..\Linker\STM32F10x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group OS
    ../OS/: heap_2.c list.c port.c portasm.s queue.c tasks.c timers.c
  group ST
    ../Library/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group Startup
    ../Library/src/: core_cm3.c
    ../Startup/: cortexm3_macro.s stm32f10x_vector.c
  group User
    ./: FreeRTOSConfig.h
    ../User/: main.c stm32f10x_it.c
  group User/common
    ../User/: comfunc.c comfunc.h
  group User/drivers
    ../User/: alloter.c alloter.h spiflash.c spiflash.h uart.c uart.h
  group User/peripheral
    ../User/: key.c key.h
  group User/usr
    ../User/: debug.c debug.h dev_ctrl.c dev_ctrl.h smart_frame.c smart_frame.h task_timer.c task_timer.h
