<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>OS</name>
    <file>
      <name>$PROJ_DIR$\..\OS\heap_2.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\OS\list.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\OS\port.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\OS\portasm.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\OS\queue.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\OS\tasks.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\OS\timers.c</name>
    </file>
  </group>
  <group>
    <name>ST</name>
    <file>
      <name>$PROJ_DIR$\..\Library\src\misc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Library\src\stm32f10x_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Library\src\stm32f10x_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Library\src\stm32f10x_lib.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Library\src\stm32f10x_rcc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Library\src\stm32f10x_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Library\src\stm32f10x_tim.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Library\src\stm32f10x_usart.c</name>
    </file>
  </group>
  <group>
    <name>Startup</name>
    <file>
      <name>$PROJ_DIR$\..\Library\src\core_cm3.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Startup\cortexm3_macro.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Startup\stm32f10x_vector.c</name>
    </file>
  </group>
  <group>
    <name>User</name>
    <group>
      <name>common</name>
      <file>
        <name>$PROJ_DIR$\..\User\comfunc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\User\comfunc.h</name>
      </file>
    </group>
    <group>
      <name>drivers</name>
      <file>
        <name>$PROJ_DIR$\..\User\alloter.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\User\alloter.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\User\spiflash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\User\spiflash.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\User\uart.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\User\uart.h</name>
      </file>
    </group>
    <group>
      <name>peripheral</name>
      <file>
        <name>$PROJ_DIR$\..\User\key.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\User\key.h</name>
      </file>
    </group>
    <group>
      <name>usr</name>
      <file>
        <name>$PROJ_DIR$\..\User\debug.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\User\debug.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\User\dev_ctrl.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\User\dev_ctrl.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\User\smart_frame.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\User\smart_frame.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\User\task_timer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\User\task_timer.h</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\FreeRTOSConfig.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\stm32f10x_it.c</name>
    </file>
  </group>
</project>


